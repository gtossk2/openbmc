RDEPENDS:${PN}-extras:append = " webui-vue v4l-utils pldm libmctp"
